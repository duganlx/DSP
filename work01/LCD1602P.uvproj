# Keil uVision project LCD1602P.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89F51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: LCD1602P +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 LCD1602.c mainX.c
